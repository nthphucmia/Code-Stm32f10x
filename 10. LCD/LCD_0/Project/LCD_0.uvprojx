# Keil uVision project LCD_0.uvprojx, settings and files
target LCD_0 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LCD_0 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\Project;..\Libraries\CMSIS\CoreSupport;..\Libraries\CMSIS\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Source\Source_DIY\inc;..\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../Source/: main.c stm32f10x_it.c
  group Std_PeriphDriver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_tim.c
  group CMSIS
    ../Source/: system_stm32f10x.c
    ../Libraries/CMSIS/CoreSupport/: core_cm3.c
  group Startup
    ../Libraries/CMSIS/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Source
    ../Source/Source_DIY/src/: delay.c LiquidCrystal_I2C.c I2C.c
